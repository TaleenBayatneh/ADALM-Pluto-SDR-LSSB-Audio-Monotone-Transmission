options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 300e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 300e3
    low_cutoff_freq: 260e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '700'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\user\Downloads\pajaros-de-madrugada-55404.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '101'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '101'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '1000000'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_2, '0', blocks_multiply_xx_1_0, '0']
- [analog_sig_source_x_2, '0', hilbert_fc_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '0']
- [blocks_float_to_complex_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_1, '1']
- [hilbert_fc_0_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1_0, '1']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
